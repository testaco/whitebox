<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radioserver_source_c</value></param>
<param><key>title</key><value>RadioServer Complex Source</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Hardware</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>uri</value></param>
<param><key>value</key><value>"ws://localhost:8080/WebSocket/"</value></param>
</block>
<block>
<key>blks2_tcp_source</key>
<param><key>id</key><value>radioserver_client_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>addr</key><value>uri</value></param>
<param><key>port</key><value>0</value></param>
<param><key>server</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>radioserver_client_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
